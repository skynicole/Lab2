# Keil uVision project labtheone.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: labtheone +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../../Desktop/skyler/: main_lab2.c startup_lab2_stm32l1xx_md.s
software components: CMSIS:CORE 4.3.0
